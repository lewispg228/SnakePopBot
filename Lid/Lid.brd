File: Lid/Lid.brd (EAGLE design)
At the start: 62.5 x 88.9 mm, 6 parts

Commit message: Lid "v4" finalized
Parts:
- added E$4: (no value), lid:CLAMP_&_HINGE
- added E$5: (no value), lid:FLAP
